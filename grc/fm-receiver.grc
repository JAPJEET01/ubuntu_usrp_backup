options:
  parameters:
    author: japjeet
    generate_options: qt_gui
    id: receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {state: disabled}
- name: sample_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 200e3
    stop: 108e6
    value: '100600000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '50e-3'
    stop: '1'
    value: '300e-3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decim
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: 192e3
    deviation: deviation
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: iridium_fft_burst_tagger_0
  id: iridium_fft_burst_tagger
  parameters:
    burst_post_len: '1000'
    burst_pre_len: '1000'
    burst_width: '100'
    center_frequency: '1626000000'
    debug: 'False'
    fft_size: '1024'
    history_size: '512'
    max_burst_len: '100'
    max_bursts: '10'
    sample_rate: int(sample_rate)
    threshold: '7'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: interp
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 500e3
    center_freq0: tuning
    gain0: '50'
    samp_rate: sample_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [iridium_fft_burst_tagger_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', iridium_fft_burst_tagger_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-664-g5884ec6d

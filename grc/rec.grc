options:
  parameters:
    generate_options: qt_gui
    id: rec
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 1.tcp.in.ngrok.io
    port: '20434'
    server: 'False'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [network_tcp_source_0, '0', audio_sink_0, '0']
- [network_tcp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
